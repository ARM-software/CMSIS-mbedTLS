# Keil uVision project ssl_server.uvprojx, settings and files
target MCB1800 (6160000::V6.16::ARMCLANG)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ssl_server
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c ssl_server.c certs.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Security:mbed TLS 3.1.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.16.0, Network:Interface:ETH 7.16.0, Network:Service:DNS Client 7.16.0, Network:Socket:BSD 7.16.0, Network:Socket:TCP 7.16.0, Network:Socket:UDP 7.16.0, CMSIS Driver:Ethernet MAC 2.11.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:SCU 1.1.0, Device:Startup 1.0.0
